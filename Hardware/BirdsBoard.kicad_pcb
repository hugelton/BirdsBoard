# Repository hugelton/BirdsBoard

File README.md:

# BirdsBoard

BirdsBoard is an open-source modular synthesizer project based on the RP2350A microcontroller and the PT8211 I2S DAC. This project provides a collection of digitally controlled oscillator (DCO) applications for Eurorack-compatible systems.

-> Based on ["Wren"](https://documents.hugelton.com/Wren) indivisual module.

## Firmware

This repository contains several firmware applications.

| Firmware   | Status         | Description                                       |
|------------|----------------|---------------------------------------------------|
| **Wren**   | Stable         | Real-time wavetable DCO with USB editing.         |
| **Tockus** | In Development | Versatile drum voice with 8 algorithms.           |
| **Tern**   | Experimental   | LFSR-based noise oscillator.                      |
| **ADC_Test**| Utility        | Utility for debugging and calibrating hardware.   |

- **Waveshare RP2350A Zero + PT8211:** A compact, affordable combination for high-quality audio synthesis.
- **Multiple Applications:** A variety of synthesizer voices with unique features.
- **Eurorack Compatible:** Designed to integrate with standard modular synthesizer systems.
- **Open Source:** Hardware and firmware are released under open-source licenses.

## Applications

A powerful wavetable oscillator with 8 user-editable wavetable banks.
> Try the online wavetable editor for Wren: [https://hugelton.com/tools/wren-editor/](https://hugelton.com/tools/wren-editor/)

### Wren
A powerful wavetable oscillator with 8 user-editable wavetable banks.
- **Real-time USB Editing:** Edit wavetables on the fly using a binary serial protocol.
- **CV Control:** Control wavetable bank selection and modulation amount via CV.
- **Multiple Modulation Types:** Wavefolding, Overflow, Bitcrushing, Phase Distortion, Resonance.
- **Hard Sync:** Reset the oscillator phase with a gate input.
- **NeoPixel Display:** An LED indicates the current wavetable bank and serial connection status.

### Tockus
A flexible drum synthesizer with 8 distinct algorithms.
- **Algorithms:** 808-style Bass Drum, Snare, Hi-hat, Karplus-Strong, and more.
- **CV Control:** Select algorithms and control a parameter for each algorithm via CV.
- **NeoPixel Display:** An LED indicates the currently selected algorithm.

### Tern
A chiptune-style noise generator based on a Linear Feedback Shift Register (LFSR).
- **CV Control:** Control the frequency, register length, and tap position of the LFSR via CV.
- **Gate Reset:** Reset the LFSR to its initial state with a gate input.

## Hardware
The hardware design files (schematics and PCB layouts) are available in the `Hardware` directory.
- **Microcontroller:** Waveshare RP2350A Zero
- **DAC:** PT8211 I2S DAC
- **CV Inputs:** 4x -5V~+5V CV inputs
- **Gate Input:** 1x Gate input

  ### JLCPCB Integration
  Just send me the design file and I'll make it all for you.
  Please prepare your own USB cable and Neopixel.

## Getting Started with arduino-cli

This project uses `arduino-cli` for building and uploading firmware.

1.  **Install `arduino-cli`:**
    Follow the official instructions: [https://arduino.github.io/arduino-cli/latest/installation/](https://arduino.github.io/arduino-cli/latest/installation/)

2.  **Clone the repository:**
    ```bash
    git clone https://github.com/kurogedelic/BirdsBoard.git
    cd BirdsBoard
    ```

3.  **Setup `arduino-cli`:**
    Update the core index and install the necessary core and libraries.
    ```bash
    # Update package index
    arduino-cli core update-index

    # Install the Raspberry Pi Pico/RP2350A core
    arduino-cli core install rp2350A:rp2350A

    # Install libraries
    arduino-cli lib install FastLED EEPROM
    ```
    *Note: The `I2S` and `pico/multicore` libraries are included with the `rp2350A:rp2350A` core.*

4.  **Compile a firmware:**
    To compile a specific firmware (e.g., Wren), run the following command. The FQBN (Fully Qualified Board Name) for the board is `rp2350A:rp2350A:pico`.
    ```bash
    arduino-cli compile --fqbn rp2350A:rp2350A:pico Firmware/Wren/
    ```

5.  **Upload the firmware:**
    First, put your board into bootloader mode and find its port.
    ```bash
    arduino-cli board list
    ```
    Then, upload the firmware. Replace `/dev/ttyACM0` with your board's port.
    ```bash
    arduino-cli upload -p /dev/ttyACM0 --fqbn rp2350A:rp2350A:pico Firmware/Wren/
    ```

## License

This project consists of both hardware and firmware components, each under its own open-source license. See the `Hardware/LICENSE` and `Firmware/LICENSE` files for full license texts.

> 📜 Hardware: CERN-OHL-S v2 / Firmware: LGPL-3.0

### Hardware License
The hardware designs (schematics, PCB layouts) are licensed under the **CERN-OHL-S v2**. A copy of the license is available in the `Hardware/` directory.
The CERN Open Hardware Licence ensures that any modifications to the hardware design are shared under the same terms, preserving openness across derivatives.

### Firmware License
The firmware applications are licensed under the **GNU Lesser General Public License v3.0 (LGPL-3.0)**. A copy of the license is available in the `Firmware/` directory.

The LGPL-3.0 allows use in both open and closed-source systems, as long as modifications to the firmware itself are released under the same license.

## Acknowledgements

This project draws inspiration and technical insight from the following excellent works:

- [**Winterbloom Big Honking Button**](https://github.com/wntrblm/Big_Honking_Button): The concept of software-swappable applications and aspects of the hardware design were greatly influenced by this project.
- [**HAGIWO/MOD2**](https://note.com/solder_state/n/nce8f7defcf98): A far more refined predecessor in the concept of modular, reprogrammable firmware architectures. 

## Contributing

Contributions are welcome!

Feel free to fork this repository, submit pull requests, or open issues if you find bugs or have feature suggestions. Whether it's hardware revisions, firmware improvements, or documentation fixes—every bit helps.

See `CONTRIBUTING.md` (coming soon) for guidelines.

## Author

**Leo Kuroshita** ([@kurogedelic](https://x.com/kurogedelic)) for ([Hügelton Instruments](https://github.com/hugelton)).

## KiCad design Hardware/BirdsBoard.kicad_pcb

Parts:
C1: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 100uF; CP_Elec_6.3x5.4_Nichicon
C4, C15: 10uF; C_0603_1608Metric; JLCPCB C85713
C5: 0.1u; C_0402_1005Metric; JLCPCB C105526
C6: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; JLCPCB C85713
C7, C9: 0.1u; C_0603_1608Metric; JLCPCB C14663
C8, C11, C12: 18p; C_0402_1005Metric
C10, C13: 0.1u; C_0402_1005Metric; JLCPCB C14663
C16: 100nF; C_0402_1005Metric; JLCPCB C282519
C17: 0.47uF; C_0402_1005Metric; JLCPCB C105526
C18: 1uF; C_0402_1005Metric; JLCPCB C1592
D1, D2: 1N5819WS; D_SOD-323
J1: Conn_02x08_Odd_Even; IDC-Header_2x08_P2.54mm_Vertical
J2: InputPitchCV; Thonk_narrowPad
J3: CV1; Thonk_narrowPad
J4: CV2; Thonk_narrowPad
J5: GateInput; Thonk_narrowPad
J6: Conn_01x10_Pin; PinHeader_1x10_P1.27mm_Vertical
J7: Output; Thonk_narrowPad
J8: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
Q1: MMBT3904; SOT-23
R1: 1k; R_0402_1005Metric
R2: 12k; R_0402_1005Metric
R3, R4: 47k; R_0402_1005Metric
R5: 10; R_0402_1005Metric
R6: 2.2k; R_0402_1005Metric
R7: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R15, R19: 100k; R_0402_1005Metric
R14, R18, R21: 33k; R_0402_1005Metric
R16, R17, R20: 200k; R_0402_1005Metric
R25: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R26: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1, RV2, RV3: 10kB; ALPS_RK09K_Single_Vertical_20mm
U1: TL072; SOIC-8_3.9x4.9mm_P1.27mm
U2: PT8211; SOP-8_3.76x4.96mm_P1.27mm
U3: RP2040-Zero-throu; RP2040-Zero-THT2
U4: LM4040DBZ-10; SOT-23
U5, U6: MCP6002-xMC; DFN-8-1EP_3x2mm_P0.5mm_EP1.75x1.45mm
U7: LD1117S50TR_SOT223; SOT-223-3_TabPin2; JLCPCB C6187
U8: XC6206PxxxMR; SOT-23-3; JLCPCB C5446

Connections:
+3V3: C10.1, C13.1, C18.1, J6.10, J8.2, R7.2, RV2.3, U3.30 (3V3), U5.8 (V+), U6.8 (V+), U8.2 (VO)
+5V: C4.1, C15.1, C17.1, J2.TN, R5.2, U3.32 (5V), U7.2 (VO), U8.3 (VI)
+12V: C6.1, C7.1, C16.1, D1.1 (K), U1.8 (V+), U7.3 (VI)
-10V: C5.1, R16.2, R17.2, R20.2, R26.1, U4.2 (A)
-12V: C9.2, D2.2 (A), R26.2, U1.4 (V-)
ADC0: C12.2, R21.1, U3.26, U5.1
ADC1: RV2.2, U3.27
ADC2: RV3.2, U3.28
ADC3: RV1.2, U3.29
DAC_BCK: U2.1 (BCK), U3.6
DAC_DATA: U2.3 (DIN), U3.8
DAC_WS: U2.2 (WS), U3.7
GND: C1.1, C4.2, C5.2, C6.2, C7.2, C9.1, C10.2, C13.2, C15.2, C16.2, C17.2, C18.2, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, J2.S, J3.S, J3.TN, J4.S, J4.TN, J5.S, J5.TN, J6.1, J6.9, J7.S, J8.1, Q1.2 (E), R3.1, R8.1, RV1.1, RV1.MP (MountPin), RV2.1, RV2.MP (MountPin), RV3.1, RV3.MP (MountPin), U1.5 (+), U2.4 (GND), U3.31 (GND), U4.1 (K), U5.3 (+), U5.4 (V-), U5.9 (V-), U6.3 (+), U6.4 (V-), U6.5 (+), U6.9 (V-), U7.1 (GND), U8.1 (GND)
INPUT_GATE: U3.2, U5.6 (-), U5.7
Jack_Out: J7.T, R1.1
METHOD_1: J8.4, U3.4
METHOD_2: J8.5, U3.5
NEOPIXEL: J8.3, U3.3
unnamed: C2.2, R6.1
unnamed: C3.2, R2.2, R3.2
unnamed: C8.2, R18.1, RV1.3, U6.7
unnamed: C11.2, R14.1, RV3.3, U6.1
unnamed: J2.T, R19.2
unnamed: J3.T, R15.2
unnamed: J4.T, R13.2
unnamed: J5.T, R8.2, R25.1
unnamed: Q1.1 (B), R25.2
unnamed: Q1.3 (C), R7.1, U5.5 (+)
unnamed: R1.2, R4.1, U1.7
unnamed: C2.1, U1.3 (+)
unnamed: C3.1, U1.1, U1.2 (-)
unnamed: R2.1, R4.2, U1.6 (-)
unnamed: R6.2, U2.6 (LCH)
unnamed: C1.2, R5.1, U2.5 (VCC)
unnamed: C12.1, R19.1, R20.1, R21.2, U5.2 (-)
unnamed: C11.1, R14.2, R15.1, R16.1, U6.2 (-)
unnamed: C8.1, R13.1, R17.1, R18.2, U6.6 (-)
RX: U3.1
SD_CS: J6.2, U3.9
SD_DAT1: J6.6, U3.13
SD_DAT2: J6.7, U3.14
SD_DAT3: J6.8, U3.15
SD_MISO: J6.5, U3.12
SD_MOSI: J6.4, U3.11
SD_SCK: J6.3, U3.10
TX: U3.0
VCC: D1.2 (A), J1.9, J1.10
VEE: D2.1 (K), J1.1, J1.2

Notes on the sheet:
CV1
not necessary now 今は不要
USB-C female
DATA
For safety reasons, always use IDC box headers. Using pin headers as a substitute is a violation of the license.
250mA
output: 3.3V
MCU
Neopixel LED :(e.g. PL9823-F5)
PitchCV
USBポートの延長ケーブルはVCCを切断します
800mA
input:2.5vpp
output: 3.3V~0V
heating caution on the board
cv(mod) input
GND
range: +5V
USB-C female
安全性のため必ずIDC ボックスヘッダを使用してください。 ピンヘッダでの代用はライセンス違反とします。
VCC
16pin and preparing the power supply
-10V Reference
Gate
48khz/2.5vpp
GATE
5V to 3.3V
Please disconnect the VCC of the USB extension cable from the RP2350A Zero.
CV2
If you want to add an SD card (not necessary now) SDカードを増設する場合（今は不要）
range: 10Vpp (-10 to +10)
アチアチに注意！
+12V to 5V
pitch / gate input

Board: 2 copper layers, 39.6 x 91.8 mm, 58 parts (4 on the bottom side), 46 nets.

File Hardware/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0603,1,100nF,
"C10, C13, C5",0402,3,0.1u,
"C11, C12, C8",0402,3,18p,
"C15, C4",0603,2,10uF,
C16,0402,1,100nF,
C17,0402,1,0.47uF,
C18,0402,1,1uF,
C2,0603,1,1uF,
C3,CP_Elec_6.3x5.4_Nichicon,1,100uF,
C6,0805,1,10uF,
"C7, C9",0603,2,0.1u,
"D1, D2",D_SOD-323,2,1N5819WS,
J1,IDC-Header_2x08_P2.54mm_Vertical,1,Conn_02x08_Odd_Even,
J2,Thonk_narrowPad,1,InputPitchCV,
J3,Thonk_narrowPad,1,CV1,
J4,Thonk_narrowPad,1,CV2,
J5,Thonk_narrowPad,1,GateInput,
J6,PinHeader_1x10_P1.27mm_Vertical,1,Conn_01x10_Pin,
J7,Thonk_narrowPad,1,Output,
J8,PinHeader_1x05_P2.54mm_Vertical,1,Conn_01x05_Pin,
Q1,SOT-23,1,MMBT3904,
R1,0402,1,1k,
"R13, R15, R19",0402,3,100k,
"R14, R18, R21",0402,3,33k,
"R16, R17, R20",0402,3,200k,
R2,0402,1,12k,
R25,0603,1,100k,
R26,0603,1,2.2k,
"R3, R4",0402,2,47k,
R5,0402,1,10,
R6,0402,1,2.2k,
R7,0603,1,10k,
R8,0603,1,1M,
"RV1, RV2, RV3",ALPS_RK09K_Single_Vertical_20mm,3,10kB,
U1,SOIC-8_3.9x4.9mm_P1.27mm,1,TL072,
U2,SOP-8_3.76x4.96mm_P1.27mm,1,PT8211,
U3,RP2040-Zero-THT2,1,RP2040-Zero-throu,
U4,SOT-23,1,LM4040DBZ-10,
"U5, U6",DFN-8-1EP_3x2mm_P0.5mm_EP1.75x1.45mm,2,MCP6002-xMC,
U7,SOT-223-3_TabPin2,1,LD1117S50TR_SOT223,
U8,SOT-23-3,1,XC6206PxxxMR,

## Commit log (part)

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2025-07-30 First Release
2025-07-30 Remove .DS_Store from tracking
2025-07-30 FUNDING.yml を更新
